# Keil uVision project Smart_Agriculture.uvprojx, settings and files
target Smart_Agriculture (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smart_Agriculture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: .\STM32F4xx_StdPeriph_Driver\Include;.\Src;.\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Design_Project\Document\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Mylib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./Src/: system_stm32f4xx.c
  group User
    ./Src/: main.c stm32f4xx_it.c
  group Std_Lib
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_tim.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c
  group Mylib
    ./Mylib/: Systick.c Systick.h I2C.c I2C.h BH1750.c BH1750.h DS18B20.c DS18B20.h Timerx.c Timerx.h GPIO.c GPIO.h ADCx.c ADCx.h MAX44009.c MAX44009.h
  group Startup
    ./Src/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.2.0
